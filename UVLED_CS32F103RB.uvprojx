# Keil uVision project UVLED_CS32F103RB.uvprojx, settings and files
target UVLED_CS32F103VB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CS32F103RB ChipSea
  pack: ChipSea.CS32F1xx_DFP.2.1.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UVLED_CS32F103RB_Pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CS32F103xB,
  c include: .\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./USER/src/: main.c sys.c gpio.c timer.c usart.c adc.c iic.c eeprom.c TM1639.c Application.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.1.0, Device:StdPeriph Drivers:ADC 2.1.0, Device:StdPeriph Drivers:BKP 2.1.0, Device:StdPeriph Drivers:CAN 2.1.0, Device:StdPeriph Drivers:CRC 2.1.0, Device:StdPeriph Drivers:DEBUG 2.1.0, Device:StdPeriph Drivers:DMA 2.1.0, Device:StdPeriph Drivers:EXTI 2.1.0, Device:StdPeriph Drivers:FWDT 2.1.0, Device:StdPeriph Drivers:Flash 2.1.0, Device:StdPeriph Drivers:Framework 2.1.0, Device:StdPeriph Drivers:GPIO 2.1.0, Device:StdPeriph Drivers:I2C 2.1.0, Device:StdPeriph Drivers:PMU 2.1.0, Device:StdPeriph Drivers:RCU 2.1.0, Device:StdPeriph Drivers:RTC 2.1.0, Device:StdPeriph Drivers:SPI 2.1.0, Device:StdPeriph Drivers:TIM 2.1.0, Device:StdPeriph Drivers:USART 2.1.0, Device:StdPeriph Drivers:WWDT 2.1.0
